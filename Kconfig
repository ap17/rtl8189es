## Kconfig
```kconfig
config RTL8189ES
	tristate "Realtek 8189ES SDIO WiFi"
	depends on USB
	---help---
	  Help message of RTL8189ES
```
